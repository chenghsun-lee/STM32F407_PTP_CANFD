# Keil uVision project Discovery.uvprojx, settings and files
target Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ARM_MATH_CM4, __FPU_PRESENT=1,__CMSIS_RTOS,__CORTEX_M4F,USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\code;.\libraries;.\libraries\STM32F4x7_ETH_Driver\inc;.\libraries\STM32F4x7_ETH_Driver\src;.\libraries\STM32F4x7_ETH_Driver;.\code\inc;..\..\libraries\RTX-v4.73;..\..\libraries\RTX-v4.73\INC;..\inc;..\..\libraries\STM32F4xx_StdPeriph_Driver;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\libraries\STM32F4x7_ETH_Driver;..\..\libraries\STM32F4x7_ETH_Driver\inc;..\..\libraries\STM32F4-Discovery;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\RTX-v4.73\SRC;..\src;..\MDK-ARM;.\Discovery;..\..\libraries\lwip-1.4.1\port\STM32F4x7\arch;..\..\libraries\lwip-1.4.1;..\..\libraries\lwip-1.4.1\port;..\..\libraries\lwip-1.4.1\port\STM32F4x7;..\..\libraries\lwip-1.4.1\src;..\..\libraries\lwip-1.4.1\src\include\lwip;..\..\libraries\lwip-1.4.1\src\include;..\..\libraries\lwip-1.4.1\src\include\ipv4\lwip;..\..\libraries\lwip-1.4.1\src\include\ipv4;..\..\libraries\lwip-1.4.1\src\include\netif;..\..\libraries\lwip-1.4.1\src\core;..\..\libraries\lwip-1.4.1\port\STM32F4x7\arch;..\..\libraries\lwip-1.4.1\port\STM32F4x7\arch;..\..\libraries;..\..\libraries\lwip-1.4.1\port\STM32F4x7\arch;..\..\libraries\ptpd-2.0.0\src\dep;..\..\libraries\ptpd-2.0.0\src;..\..\libraries\ptpd-2.0.0;..\..\libraries;..\..\libraries\time_msg;..\..\libraries\PTPD;..\..\libraries\ptpd-2.0.0\src\dep;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS;..\..\libraries\CMSIS\DSP_Lib;..\..\libraries\CMSIS\DSP_Lib\Source\TransformFunctions;..\..\libraries\CANFD\app;..\..\libraries\CANFD\canfdspi;..\..\libraries\CANFD\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: main.c stm32f4x7_eth_bsp.c stm32f4xx_it.c system_stm32f4xx.c Lab612_TIM.c Lab612_TIM_IT.c Lab612_ADC.c
  group RTX Configuration
    ../src/: RTX_Conf_CM.c
  group RTX Kernel
    ../../libraries/RTX-v4.73/SRC/: rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c
  group RTX HAL
    ../../libraries/RTX-v4.73/SRC/ARM/: SVC_Table.s HAL_CM4.c
    ../../libraries/RTX-v4.73/SRC/: HAL_CM.c
  group STM32F4-Discovery
    ../../libraries/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lcd.c
  group STM32F4xx_StdPeriph_Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_spi.c
  group STM32F4x7_ETH_Driver
    ../../libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group ETH
    ../src/: netconf.c
    ../../libraries/lwip-1.4.1/port/STM32F4x7/arch/: ethernetif.c sys_arch.c
    ../../libraries/lwip-1.4.1/src/core/: pbuf.c memp.c mem.c
  group time_msg
    ../../libraries/time_msg/: time_msg.c
  group PTPD
    ../../libraries/ptpd-2.0.0/src/: ptpd.c protocol.c bmc.c arith.c
    ../../libraries/ptpd-2.0.0/src/dep/: net.c startup.c timer.c sys_time.c servo.c msg.c
    ../../libraries/lwip-1.4.1/src/core/: def.c
  group DSP
    ../../libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../../libraries/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
    ../../libraries/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
    ../../libraries/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ../../libraries/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
    ../../libraries/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c arm_max_q7.c arm_max_q15.c arm_max_q31.c arm_mean_f32.c arm_mean_q7.c arm_mean_q15.c arm_mean_q31.c arm_min_f32.c arm_min_q7.c arm_min_q15.c arm_min_q31.c arm_power_f32.c arm_power_q7.c arm_power_q15.c arm_power_q31.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
  group CANFD
    ../../libraries/CANFD/app/: app.c app.h asf.h
    ../../libraries/CANFD/canfdspi/: drv_canfdspi_api.c drv_canfdspi_api.h drv_canfdspi_defines.h drv_canfdspi_register.h
    ../../libraries/CANFD/spi/: drv_spi.c drv_spi.h
software components: CMSIS:CORE 5.3.0
